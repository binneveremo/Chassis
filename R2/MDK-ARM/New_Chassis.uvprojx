# Keil uVision project New_Chassis.uvprojx, settings and files
target New_Chassis (6220000::V6.22::ARMCLANG)
  device: STM32H723ZGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: New_Chassis
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx,USE_PWR_LDO_SUPPLY
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;./Can;./Carrot;./Donkey;./GamePad;./Global;./Master;./CPU;./Position;./Communication;./Filter;./Correct;./Debug;./RGB;./Guard;./Xuan;./Basket;./SPI_FDCAN;..\lib\eigen
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Can
    ./Can/: Can_Bsp.c Can_Bsp.h
  group Donkey
    ./Donkey/: Chassis.c Chassis.h VESC.c VESC.h HO7213.c HO7213.h 需要修改的东西.txt
  group Global
    ./Global/: Global.c Global.h
  group Master
    ./Master/: Fake_Rtos.c Fake_Rtos.h Flow.c Flow.h
  group Position
    ./Position/: Encoder.c Encoder.h Gyro.c Gyro.h Location.c Location.h 定位说明.txt
  group Communication
    ./Communication/: Communication.c Communication.h Television.c Television.h
  group Filter
    ./Filter/: Kalman.c Kalman.h Second_Order.cpp Second_Order.hpp
  group Correct
    ./Correct/: Correct.c Correct.h
  group UART
    ./Debug/: Send.c Send.h
  group RGB
    ./RGB/: RGB.c RGB.h
  group Guard
    ./Guard/: Guard.c Guard.h
  group Xuan
    ./Xuan/: Interact.c Interact.h catchball.c catchball.h HighTorque.c HighTorque.h
  group CPU
    ./CPU/: CPU_Load.c CPU_Load.h
  group GamePad
    ./GamePad/: mine.c mine.h 手柄按键映射.txt crc8.c crc8.h mngCommu.c mngCommu.h mySerial.c mySerial.h Nrf.c Nrf.h recDecode.c recDecode.h zigbee.c zigbee.h
  group Basket
    ./Basket/: Basket.c Basket.h
  group SPI_FDCAN
    ./SPI_FDCAN/: drv_canfdspi_api.c drv_canfdspi_api.h drv_canfdspi_defines.h drv_canfdspi_register.h drv_spi.c drv_spi.h SPI_FDCAN.c SPI_FDCAN.h
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
